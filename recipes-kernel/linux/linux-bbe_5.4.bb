#BRANCH = "linux-sancloud-5.4.y"
BRANCH = "pbarker/bbei-wifi"
SRCREV = "68941148bf7fe954abcc9f7460d4d08457e5a59c"
PV = "5.4.10+git${SRCPV}"

require linux-bbe-5.4.inc
